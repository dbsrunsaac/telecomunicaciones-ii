options:
  parameters:
    author: bremdow
    generate_options: qt_gui
    id: mod_qam
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '{1, -1, -1, 1, 3, 3, 1, -1, -3, -3, -3, -3, -1, 3, 3, 1}'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '{1, 1, -1, -1, 1, 3, 3, 3, 3, 1, -1, -3, -3, -1, -3, -3}'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: samp_per_sym
    taps: np.hstack((1, np.zeros(samp_per_sym - 1)))
    type: fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_1, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_1, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
